## Kconfig
```kconfig
config RTL8822CE
	tristate "Realtek 8822C PCIE WiFi"
	depends on PCI
	---help---
	  Help message of RTL8822CE
```
